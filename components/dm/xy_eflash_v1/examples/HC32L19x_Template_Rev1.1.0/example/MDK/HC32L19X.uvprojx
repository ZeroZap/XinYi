# Keil uVision project HC32L19X.uvprojx, settings and files
target HC32L19X_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: HC32L19X +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\..\common;..\source;..\..\..\..\..\EEPROM;..\..\..\..\mcu;..\..\driver\inc;..\..\..\..\..\..\..\..\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l19x.s
    ../../common/: system_hc32l19x.c interrupts_hc32l19x.c
    ../../../../../../../../common/: xy_ctype.c xy_delay.c xy_stdio.c xy_string.c
  group source
    ../source/: main.c
  group eeprom
    ../../../../mcu/: eep_hc32lxx.c
    ../../../../: eep.c
    ../../driver/src/: sysctrl.c
  group driver
    ../../driver/src/: flash.c ddl.c uart.c
software components: CMSIS:CORE 4.1.0
