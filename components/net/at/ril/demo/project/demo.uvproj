# Keil uVision project demo.uvproj, settings and files
target demo (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ril
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99 --gnu
  c include: ..\driver\inc;..\lib\CMSIS\Include;..\lib\STM32F4xx_StdPeriph_Driver\inc;..\os\FreeRTOS\Source\include;..\os\FreeRTOS;..\os\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\user;..\..\ril\case\;..\..\ril\case\MQTTPacket;..\..\ril\common\inc;..\..\ril\core\inc;..\..\ril\port;..\misc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group driver
    ../driver/src/: tty.c module_uart.c
  group lib/CMSIS
    ../lib/CMSIS/STM32F4xx/Source/: system_stm32f4xx.c
    ../lib/CMSIS/STM32F4xx/Source/arm/: startup_stm32f4xx.s
  group lib/STM32F4xx_StdPeriph_Driver
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_exti.c
  group misc
    ../misc/: cli.c
  group os/FreeRTOS/portable
    ../os/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../os/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group os/FreeRTOS/src
    ../os/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group os/FreeRTOS/config
    ../os/FreeRTOS/: FreeRTOSConfig.h FreeRTOSHook.c os_port.h
  group ril/port
    ../../ril/port/: ril_freertos.c
  group ril/core
    ../../ril/core/src/: at.c ril.c ril_core.c ril_socket.c sms.c ril_device.c ril_device_common.c
  group ril/case
    ../../ril/case/: http_client.c mqtt_client.c tftp_client.c
  group ril/case/MQTTPacket
    ../../ril/case/MQTTPacket/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group ril/modules
    ../../ril/modules/: hl8518.c quectel.c sim800c.c
  group ril/common
    ../../ril/common/src/: async_work.c ringbuffer.c string_tools.c
  group user
    ../user/: config.c main.c platform.c public.c stm32f4xx_it.c taskManager.c
  group task
    ../user/tasks/: cli_task.c ril_task.c
  group samples
    ../user/samples/: sample_http.c sample_read_imei.c sample_sms.c sample_tcp.c sample_tftp.c sample_udp.c sample_mqtt.c
