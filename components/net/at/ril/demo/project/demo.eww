<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\demo.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\ril\build\ril.ewp</path>
  </project>
  <batchBuild/>
</workspace>


