# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xD ST STM32F401xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\ril\port; ..\..\ril\core\inc; ..\..\ril\common\inc; ..\..\ril\case\MQTTPacket; ..\..\ril\case\; ..\driver\inc; ..\misc; ..\user; ..\user\samples; ..\os\FreeRTOS\; ..\os\FreeRTOS\Source\include; ..\os\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\lib\CMSIS\Include; ..\lib\CMSIS\STM32F4xx\Include; ..\lib\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\os\FreeRTOS\
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group driver
    ../driver/src/: module_uart.c tty.c
  group lib/CMSIS
    ../lib/CMSIS/STM32F4xx/Source/iar/: startup_stm32f4xx.s
    ../lib/CMSIS/STM32F4xx/Source/: system_stm32f4xx.c
  group lib/STM32F4xx_StdPeriph_Driver
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group misc
    ../misc/: cli.c
  group os/FreeRTOS
    ../os/FreeRTOS/: FreeRTOSConfig.h FreeRTOSHook.c os_port.h
  group os/FreeRTOS/portable
    ../os/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../os/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group os/FreeRTOS/src
    ../os/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group ril/case
    ../../ril/case/: http_client.c mqtt_client.c tftp_client.c
  group ril/case/MQTTPacket
    ../../ril/case/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group ril/common
    ../../ril/common/src/: async_work.c ringbuffer.c string_tools.c
  group ril/core
    ../../ril/core/src/: at.c ril.c ril_core.c ril_device.c ril_device_common.c ril_socket.c sms.c
  group ril/modules
    ../../ril/modules/: hl8518.c quectel.c sim800c.c
  group ril/port
    ../../ril/port/: ril_freertos.c
  group user
    ../user/: config.c main.c platform.c public.c stm32f4xx_conf.h stm32f4xx_it.c taskManager.c
  group user/samples
    ../user/samples/: sample_http.c sample_mqtt.c sample_read_imei.c sample_sms.c sample_tcp.c sample_tftp.c sample_udp.c
  group user/task
    ../user/tasks/: cli_task.c ril_task.c
